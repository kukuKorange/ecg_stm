# Keil uVision project Fire_F103C8.uvprojx, settings and files
target test (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Fire_F103C8 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB,ARM_MATH_CM3,USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\User;..\Drivers\STM32F1xx_HAL_Driver\Inc;..\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\User\max30102;..\Drivers\CMSIS\DSP\Include;..\Drivers\CMSIS\Lib\ARM;..\User\oled;..\Drivers\driver_basic;..\Drivers\driver_basic\inc;..\User\esp01s;..\User\ad8232;..\User\module\display;..\User\module\transmit;..\User\ecg_sim;..\User\ds18b20
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
  group CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group USER
    ../User/: main.c stm32f1xx_it.c stm32f10x_conf.h stm32f1xx_hal_conf.h Timer1.c Timer2.c
    ../User/led/: bsp_led.c
    ../User/usart/: bsp_debug_usart.c
    ../User/max30102/: max30102.c max30102_fir.c
    ../User/i2c/: bsp_i2c.c
    ../User/oled/: OLED.c OLED_Data.c
    ../User/esp01s/: esp8266.c usart2.c Key.c
    ../User/ad8232/: AD.c AD8232.c
    ../User/ecg_sim/: ecg_sim.c
    ../User/ds18b20/: ds18b20.c
  group DOC
    ../Doc/: readme.txt
  group DSP
    ../Drivers/CMSIS/Lib/ARM/: arm_cortexM3l_math.lib
  group DRIVER
    ../Drivers/driver_basic/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_tim.c misc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_flash.c stm32f10x_spi.c stm32f10x_i2c.c stm32f10x_exti.c
  group module
    ../User/module/display/: display.c
    ../User/module/transmit/: transmit.c
